# IAR project efr32.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: $--partNumber--$ SiliconLaboratories $--partNumber--$
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_EFR32; $--chipFamily;U--$; $--partNumber--$; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/$--deviceName--$/$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--stackDirFromProjBs--$\app\framework\include; $--stackDirFromProjBs--$\stack; $--halDirFromProjBs--$; $--halDirFromProjBs--$\..; $--stackDirFromProjBs--$\submodules\Device\SiliconLabs\$--chipFamily--$\Include\; $--stackDirFromProjBs--$\submodules\CMSIS\Include\; $--stackDirFromProjBs--$\submodules\emlib\inc\; $--stackDirFromProjBs--$\submodules\emdrv\common\inc; $--stackDirFromProjBs--$\submodules\emdrv\rtcdrv\inc; $--stackDirFromProjBs--$\submodules\emdrv\rtcdrv\test; $--stackDirFromProjBs--$\submodules\emdrv\sleep\inc; $--stackDirFromProjBs--$\submodules\emdrv\trace\inc; $--stackDirFromProjBs--$\submodules\emdrv\gpiointerrupt\inc; $--stackDirFromProjBs--$\submodules\emdrv\ecode; $--stackDirFromProjBs--$\submodules\emdrv\config; $--stackDirFromProjBs--$\submodules\emdrv\uartdrv\inc; $--stackDirFromProjBs--$\submodules\emdrv\spidrv\inc; $--stackDirFromProjBs--$\submodules\emdrv\dmadrv\inc; $--stackDirFromProjBs--$\submodules\emdrv\ustimer\inc; $--stackDirFromProjBs--$\submodules\emdrv\rtcdrv\inc; $--stackDirFromProjBs--$\app\util\; $--stackDirFromProjBs--$\submodules\kits\common\bsp\; $--stackDirFromProjBs--$\submodules\emdrv\gpiointerrupt\inc\; $--stackDirFromProjBs--$\submodules\emdrv\uartdrv\inc\; $--stackDirFromProjBs--$\submodules\emdrv\ustimer\inc\; $--stackDirFromProjBs--$\submodules\emdrv\rtcdrv\inc\; $--stackDirFromProjBs--$\submodules\emdrv\common\inc\; $--stackDirFromProjBs--$\submodules\emdrv\config\; $--stackDirFromProjBs--$\submodules\emdrv\dmadrv\inc\; $--stackDirFromProjBs--$\submodules\emdrv\tempdrv\inc\; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32\; $--stackDirFromProjBs--$\submodules\emdrv\trace\inc\; $--halDirFromProjBs--$\micro\cortexm3\efm32\; $--stackDirFromProjBs--$\submodules\efrseq\rfprotocol\ieee802154\cortex; $--stackDirFromProjBs--$\submodules\efrseq\common\cortex; $--stackDirFromProjBs--$\submodules\s029_efr4fpga_drv\inc; $--stackDirFromProjBs--$\submodules\reptile\glib; $--stackDirFromProjBs--$\submodules\reptile\glib\glib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_EFR32; $--chipFamily;U--$; $--partNumber--$; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/$--deviceName--$/$--tokenHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--stackDirFromProjBs--$\app\framework\include; $--stackDirFromProjBs--$\stack; $--halDirFromProjBs--$; $--halDirFromProjBs--$\..
  OBJCOPY.OOCOutputFile: $--deviceName--$.bin
  postbuild: $--deviceName--$.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: $--bootloader--$=1
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ./: call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    $--halDirFromProjFs--$/micro/cortexm3/efm32/: adc.c assert-crash-handlers.c button.c buzzer.c cstartup-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token-def.c token.c
    ../../framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    ../../framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../util/serial/: command-interpreter2.c serial.c com.c
    $--halDirFromProjFs--$/micro/generic/: crc.c endian.c mem-util.c random.c
    $--halDirFromProjFs--$/: ember-configuration.c
    ../../../build/hal-library-cortexm3-iar-$--chipFamily;L--$-efr32/: hal-library.a
    $--stackDirFromProjFs--$/submodules/kits/common/bsp/: bsp_stk_leds.c
    ../../util/common/: library.c
    ../../framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../util/security/: security-address-cache.c
    _replace_halDirFromProjFs_/micro/cortexm3/efm32/: ext-device.c
    ../../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group EMDRV
    $--stackDirFromProjBs--$/submodules/emdrv/dmadrv/src/: dmadrv.c
    $--stackDirFromProjBs--$/submodules/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    $--stackDirFromProjBs--$/submodules/emdrv/rtcdrv/src/: rtcdriver.c
    $--stackDirFromProjBs--$/submodules/emdrv/sleep/src/: sleep.c
    $--stackDirFromProjBs--$/submodules/emdrv/tempdrv/src/: tempdrv.c
    $--stackDirFromProjBs--$/submodules/emdrv/trace/src/: trace.c
    $--stackDirFromProjBs--$/submodules/emdrv/uartdrv/src/: uartdrv.c
    $--stackDirFromProjBs--$/submodules/emdrv/ustimer/src/: ustimer.c
  group EMLIB
    $--stackDirFromProjBs--$/submodules/emlib/src/: em_adc.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    $--stackDirFromProjBs--$/submodules/Device/SiliconLabs/$--chipFamily;U--$/Source/: system_$--chipFamily;L--$.c
