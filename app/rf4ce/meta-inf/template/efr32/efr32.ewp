# IAR project efr32.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: $--partNumber--$ SiliconLaboratories $--partNumber--$
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; PHY_EFR32; $--chipFamily;U--$; $--partNumber--$; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--stackDirFromProjBs--$\app\rf4ce\include; $--stackDirFromProjBs--$\app\util; $--stackDirFromProjBs--$\stack; $--halDirFromProjBs--$; $--halDirFromProjBs--$\..; $--stackDirFromProjBs--$\submodules\Device\SiliconLabs\$--chipFamily--$\Include; $--stackDirFromProjBs--$\submodules\CMSIS\Include; $--stackDirFromProjBs--$\submodules\emlib\inc; $--stackDirFromProjBs--$\submodules\emdrv\common\inc; $--stackDirFromProjBs--$\submodules\emdrv\rtcdrv\inc; $--stackDirFromProjBs--$\submodules\emdrv\rtcdrv\test; $--stackDirFromProjBs--$\submodules\emdrv\sleep\inc; $--stackDirFromProjBs--$\submodules\emdrv\trace\inc; $--stackDirFromProjBs--$\submodules\emdrv\gpiointerrupt\inc; $--stackDirFromProjBs--$\submodules\emdrv\config; $--stackDirFromProjBs--$\submodules\emdrv\uartdrv\inc; $--stackDirFromProjBs--$\submodules\emdrv\spidrv\inc; $--stackDirFromProjBs--$\submodules\emdrv\dmadrv\inc; $--stackDirFromProjBs--$\submodules\emdrv\ustimer\inc; $--stackDirFromProjBs--$\submodules\emdrv\tempdrv\inc; $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32; $--halDirFromProjBs--$\micro\cortexm3\efm32; $--stackDirFromProjBs--$\submodules\efrseq\rfprotocol\ieee802154\cortex; $--stackDirFromProjBs--$\submodules\efrseq\common\cortex; $--stackDirFromProjBs--$\submodules\s029_efr4fpga_drv\inc; $--stackDirFromProjBs--$\submodules\reptile\glib; $--stackDirFromProjBs--$\submodules\reptile\glib\glib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_EFR32; $--chipFamily;U--$; $--partNumber--$; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--stackDirFromProjBs--$\app\rf4ce\include; $--stackDirFromProjBs--$\app\util; $--stackDirFromProjBs--$\stack; $--halDirFromProjBs--$; $--halDirFromProjBs--$\..
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  prebuild: $--deviceName--$-prebuild.bat $PROJ_DIR$
  postbuild: $--deviceName--$-postbuild.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: $--bootloader--$=1
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\efm32\efr32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group emdrv
    $--stackDirFromProjBs--$/submodules/emdrv/dmadrv/src/: dmadrv.c
    $--stackDirFromProjBs--$/submodules/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    $--stackDirFromProjBs--$/submodules/emdrv/rtcdrv/src/: rtcdriver.c
    $--stackDirFromProjBs--$/submodules/emdrv/sleep/src/: sleep.c
    $--stackDirFromProjBs--$/submodules/emdrv/spidrv/src/: spidrv.c
    $--stackDirFromProjBs--$/submodules/emdrv/tempdrv/src/: tempdrv.c
    $--stackDirFromProjBs--$/submodules/emdrv/trace/src/: trace.c
    $--stackDirFromProjBs--$/submodules/emdrv/uartdrv/src/: uartdrv.c
    $--stackDirFromProjBs--$/submodules/emdrv/ustimer/src/: ustimer.c
  group emlib
    $--stackDirFromProjBs--$/submodules/emlib/src/: em_adc.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    $--stackDirFromProjBs--$/submodules/Device/SiliconLabs/$--chipFamily;U--$/Source/: system_$--chipFamily;L--$.c
