<?xml version="1.0" encoding="iso-8859-1"?>
<!-- This file was generated by Ember Desktop from the following template:
       app/ncp/meta-inf/template/em3xx/em3xx.eww
     Please do not edit it directly.
-->

<workspace>
  <project>
    <path>$WS_DIR$\$--deviceName--$.ewp</path>
  </project>
  <batchBuild/>
</workspace>
