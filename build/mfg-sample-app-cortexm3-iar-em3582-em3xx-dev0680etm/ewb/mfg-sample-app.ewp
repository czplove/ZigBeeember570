# IAR project mfg-sample-app.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3582; PHY_EM3XX; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; CONFIGURATION_HEADER="app/mfglib/mfg-lib-sample-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL0_DEBUG; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\; ../../../app/util; ../../../hal/micro/cortexm3/common; ../../../lwip/; ../../../lwip/src/include/; ../../../lwip/contrib/port/FreeRTOS/EM358X/; ../../../lwip/src/include/ipv4/; ../../../lwip/src/include/ipv6/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3582; PHY_EM3XX; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; CONFIGURATION_HEADER="app/mfglib/mfg-lib-sample-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL0_DEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mfg-sample-app.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: mfg-sample-app.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=256K; RAM_SIZE=32K
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em3582/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c antenna.c assert-crash-handlers.c bootloader-interface.c bootloader-interface-app.c bootloader-interface-standalone.c button.c buzzer.c cstartup-common.c diagnostic.c ext-device.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro.c micro-common.c mpu.c sleep.c spi-master.c token.c token-def.c uart.c
    ../../../build/alarm-library-cortexm3-iar-em3582-em3xx/: alarm-library.a
    ../../../build/binding-table-stub-library-cortexm3-iar-em3582-em3xx/: binding-table-stub-library.a
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c descriptors.c
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-em3582-em3xx/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-em3582-em3xx/: cbke-283k1-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-em3582-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-em3582-em3xx/: cbke-library-dsa-verify-283k1-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-em3582-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-em3582-em3xx/: cbke-stub-library.a
    ../../../app/util/serial/: cli.c ember-printf.c serial.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../build/debug-basic-library-cortexm3-iar-em3582-em3xx/: debug-basic-library.a
    ../../../build/debug-extended-stub-library-cortexm3-iar-em3582-em3xx/: debug-extended-stub-library.a
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c em_usbtimer.c
    ../../../hal/: ember-configuration.c
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em3582-em3xx/: end-device-bind-stub-library.a
    ../../../build/enhanced-beacon-request-stub-library-cortexm3-iar-em3582-em3xx/: enhanced-beacon-request-stub-library.a
    ../../../build/gp-stub-library-cortexm3-iar-em3582-em3xx/: gp-stub-library.a
    ../../../build/hal-library-cortexm3-iar-em3582-em3xx/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em3582-em3xx/: install-code-library-stub.a
    ../../../build/mfglib-library-cortexm3-iar-em3582-em3xx/: mfglib-library.a
    ../../../app/mfglib/: mfg-sample.c
    ../../../build/multi-network-stub-library-cortexm3-iar-em3582-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em3582-em3xx/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-em3582-em3xx/: rf4ce-stack-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-em3582-em3xx/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em3582-em3xx/: security-library-link-keys-stub.a
    ../../../build/sim-eeprom1-library-cortexm3-iar-em3582-em3xx/: sim-eeprom1-library.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-em3582-em3xx/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em3582-em3xx/: zll-stub-library.a
