# IAR project mfg-sample-app.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFR32MG1P133F256GM48 SiliconLaboratories EFR32MG1P133F256GM48
  ICCARM.CCDefines: NULL_BTL; BOARD_HEADER="hal/micro/cortexm3/efm32/board/brd4151a.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EFR32; PHY_EFR32; BOARD_BRD4151A; CORTEXM3_EFM32_MICRO; EFR32MG1P232F256GM48; EFR32MG1P; CORTEXM3_EFR32_MICRO; AESDRV_HWACCEL_DMA_ENABLED=false; RTCDRV_USE_LFRCO; CONFIGURATION_HEADER="app/mfglib/mfg-lib-sample-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL0_DEBUG; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\; ../../../app/util; ../../../submodules/emdrv/common/inc; ../../../submodules/emdrv/rtcdrv/inc; ../../../submodules/emdrv/rtcdrv/test; ../../../submodules/emdrv/sleep/inc; ../../../submodules/emdrv/aesdrv/inc; ../../../submodules/emdrv/aesdrv/src; ../../../submodules/emdrv/trace/inc; ../../../submodules/emdrv/gpiointerrupt/inc; ../../../submodules/emdrv/ecode; ../../../submodules/emdrv/config; ../../../submodules/emdrv/uartdrv/inc; ../../../submodules/emdrv/spidrv/inc; ../../../submodules/emdrv/dmadrv/inc; ../../../submodules/emdrv/ustimer/inc; ../../../submodules/emdrv/cryptodrv/src; ../../../submodules/emdrv/tempdrv/inc; ../../../hal/micro/cortexm3/common; ../../../submodules/emlib/inc; ../../../submodules/emdrv/rtcdrv/inc; ../../../submodules/CMSIS/Include; ../../../submodules/kits/common/bsp; ../../../submodules/kits/common/drivers; ../../../hal/micro/cortexm3/efm32; ../../../hal/micro/cortexm3/efm32/efr32; ../../../submodules/reptile/glib; ../../../submodules/reptile/glib/glib; ../../../submodules/reptile/glib/dmd; ../../../submodules/Device/SiliconLabs/EFR32MG1P/Include; ../../../submodules/kits/EFR32MG1_BRD4151A/config; ../../../submodules/efrseq/rfprotocol/ieee802154/cortex; ../../../submodules/efrseq/rfprotocol/ieee802154/config; ../../../submodules/efrseq/rfprotocol/ieee802154; ../../../submodules/efrseq/common/cortex; ../../../submodules/efrseq/common; ../../../submodules/emdrv/cryptodrv/src; ../../../lwip/; ../../../lwip/src/include/; ../../../lwip/contrib/port/FreeRTOS/EM358X/; ../../../lwip/src/include/ipv4/; ../../../lwip/src/include/ipv6/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NULL_BTL; BOARD_HEADER="hal/micro/cortexm3/efm32/board/brd4151a.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EFR32; PHY_EFR32; BOARD_BRD4151A; CORTEXM3_EFM32_MICRO; EFR32MG1P232F256GM48; EFR32MG1P; CORTEXM3_EFR32_MICRO; AESDRV_HWACCEL_DMA_ENABLED=false; RTCDRV_USE_LFRCO; CONFIGURATION_HEADER="app/mfglib/mfg-lib-sample-configuration.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL0_DEBUG
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\; ..\..\..\rtos\FreeRTOS\; ..\..\..\rtos\FreeRTOS\Source\; ..\..\..\rtos\FreeRTOS\Source\include; ..\..\..\rtos\FreeRTOS\Source\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: mfg-sample-app.bin
  postbuild: "ielftool.exe" "$TARGET_BPATH$.out" "$TARGET_BPATH$.s37" --srec --srec-s3only
  ILINK.IlinkOutputFile: mfg-sample-app.out
  ILINK.IlinkConfigDefines: BTL_SIZE=0K; NULL_BTL=1; FLASH_SIZE=256K; RAM_SIZE=32K
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/efm32/efr32/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/efm32/: adc.c assert-crash-handlers.c bootloader-interface.c bootloader-interface-app.c bootloader-interface-standalone.c button.c buzzer.c cstartup-common.c diagnostic.c ext-device.c faults.s79 graphics.c isr-stubs.s79 led.c mfg-token.c micro.c micro-common.c mpu.c sleep-efm32.c symbol-timer.c token.c token-def.c
    ../../../build/alarm-library-cortexm3-iar-efr32mg1p-efr32/: alarm-library.a
    ../../../hal/micro/generic/: antenna-stub.c crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../build/binding-table-stub-library-cortexm3-iar-efr32mg1p-efr32/: binding-table-stub-library.a
    ../../../submodules/kits/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-efr32mg1p-efr32/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-efr32mg1p-efr32/: cbke-283k1-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg1p-efr32/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg1p-efr32/: cbke-library-dsa-verify-283k1-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg1p-efr32/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-efr32mg1p-efr32/: cbke-stub-library.a
    ../../../app/util/serial/: cli.c com.c ember-printf.c serial.c
    ../../../build/debug-basic-library-cortexm3-iar-efr32mg1p-efr32/: debug-basic-library.a
    ../../../build/debug-extended-stub-library-cortexm3-iar-efr32mg1p-efr32/: debug-extended-stub-library.a
    ../../../submodules/kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c dmactrl.c retargetio.c retargetserial.c udelay.c
    ../../../submodules/emdrv/dmadrv/src/: dmadrv.c
    ../../../submodules/reptile/glib/dmd/display/: dmd_display.c
    ../../../submodules/emlib/src/: em_adc.c em_cmu.c em_cryotimer.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../hal/: ember-configuration.c
    ../../../build/end-device-bind-stub-library-cortexm3-iar-efr32mg1p-efr32/: end-device-bind-stub-library.a
    ../../../build/enhanced-beacon-request-stub-library-cortexm3-iar-efr32mg1p-efr32/: enhanced-beacon-request-stub-library.a
    ../../../submodules/reptile/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_font_narrow_6x8.c glib_font_normal_8x8.c glib_line.c glib_rectangle.c glib_string.c
    ../../../submodules/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../build/gp-stub-library-cortexm3-iar-efr32mg1p-efr32/: gp-stub-library.a
    ../../../build/hal-library-cortexm3-iar-efr32mg1p-efr32/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-efr32mg1p-efr32/: install-code-library-stub.a
    ../../../build/mfglib-library-cortexm3-iar-efr32mg1p-efr32/: mfglib-library.a
    ../../../app/mfglib/: mfg-sample.c
    ../../../build/multi-network-stub-library-cortexm3-iar-efr32mg1p-efr32/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-efr32mg1p-efr32/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-efr32mg1p-efr32/: rf4ce-stack-stub-library.a
    ../../../submodules/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../build/security-library-core-cortexm3-iar-efr32mg1p-efr32/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-efr32mg1p-efr32/: security-library-link-keys-stub.a
    ../../../build/sim-eeprom1-library-cortexm3-iar-efr32mg1p-efr32/: sim-eeprom1-library.a
    ../../../submodules/emdrv/sleep/src/: sleep.c
    ../../../submodules/Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
    ../../../submodules/emdrv/tempdrv/src/: tempdrv.c
    ../../../submodules/emdrv/trace/src/: trace.c
    ../../../submodules/emdrv/uartdrv/src/: uartdrv.c
    ../../../submodules/emdrv/ustimer/src/: ustimer.c
    ../../../build/zigbee-pro-stack-cortexm3-iar-efr32mg1p-efr32/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-efr32mg1p-efr32/: zll-stub-library.a
